# Keil uVision project Mini_Klavier.uvprojx, settings and files
target ARM_Minimalsystem (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mini_Klavier
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: mini_klavier.s
software components: HTL Hollabrunn:Assembler:Includes 2.0.0, HTL Hollabrunn:Assembler:Startup 1.0.0
